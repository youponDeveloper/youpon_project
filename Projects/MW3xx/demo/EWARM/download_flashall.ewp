# IAR project download_flashall.ewp, settings and files
configuration EMW3031 (ARM)
  General.OGChipSelectEditMenu: STM32F205RG ST STM32F205RG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: download_flashall.bin
  ILINK.IlinkOutputFile: flash_all_EMW3031.out
  ILINK.IlinkKeepSymbols: MYSYM
  ILINK.IlinkIcfFile: ..\..\..\..\Platform\MCU\MW3xx\interface\flash_all.icf
  ILINK.IlinkExtraOptions: --redirect malloc=_malloc; --redirect free=_free; --redirect calloc=_calloc; --redirect realloc=_realloc
  ILINK.IlinkProgramEntryLabel: MYSYM
configuration EMW5031 (ARM)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\..\Platform\MCU\MW310\interface\flash_all.icf
configuration MK3031 (ARM)
  as the first configuration, except:
  group (top)
    ../../../../platform/MCU/MW3xx/interface/: flashall.c
