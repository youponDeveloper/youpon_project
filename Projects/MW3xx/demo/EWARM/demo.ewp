# IAR project demo.ewp, settings and files
configuration MK3031 (ARM)
  General.OGChipSelectEditMenu: STM32F205RG ST STM32F205RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MICO_KERNEL; MOC; mocOS_VERSION="v1.0"
  ICCARM.CCDiagSuppress: Pa050, Pe301
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\demos\net\http\http_client_demo; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\Board\MK3031; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\platform\MCU\MW3xx\peripherals; ..\..\..\..\platform\MCU\MW3xx\moc; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform; ..\..\..\..\Platform\MCU; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries; ..\..\..\..\libraries\protocols\SNTP; ..\..\..\..\MICO\core; ..\..\..\..\MICO\security; ..\..\..\..\MICO\system; ..\..\..\..\mico\system\qc_test\internal; ..\..\..\..\mico\system\qc_test; ..\..\..\..\Platform\Drivers; ..\..\..\..\Platform\Drivers\micokit_ext; ..\..\..\..\Platform\MCU\MW3xx\interface; ..\..\..\..\Platform\MCU\MW3xx\peripherals; ..\..\..\..\Platform\MCU\MW3xx\peripherals/sdk/src/incl/sdk; ..\..\..\..\Platform\MCU\MW3xx\peripherals/sdk/src/incl/platform/os/micortos; ..\..\..\..\Platform\MCU\MW3xx\peripherals/sdk/src/incl/sdk/drivers; ..\..\..\..\Platform\MCU\MW3xx\peripherals/sdk/src/incl/sdk/drivers/mw300; ..\..\..\..\Platform\MCU\MW3xx\peripherals/sdk/src/incl/sdk/drivers/mw300/regs; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\libraries\drivers; ..\..\..\..\MiCO\RTOS\mocOS\mico; ..\..\..\..\libraries\drivers\keypad\gpio_button; ..\..\..\..\platform\MCU\MW3xx; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\libraries\utilities\base64; ..\..\..\..\libraries\drivers\ST1615; ..\..\..\..\libraries\drivers\sn3236; ..\..\..\..\demos\application\youpon; ..\..\..\..\demos\application\xlinkapp; ..\..\..\..\demos\application\xlinksrc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: demo.bin
  postbuild: CSCRIPT "postbuild.vbs" "$PROJ_DIR$" "$EXE_DIR$" "$CONFIG_NAME$"
  ILINK.IlinkOutputFile: COM.MXCHIP.BASIC.out
  ILINK.IlinkIcfFile: ..\..\..\..\Platform\MCU\MW3xx\interface\user_app.icf
  ILINK.IlinkExtraOptions: --redirect malloc=_malloc; --redirect free=_free; --redirect calloc=_calloc; --redirect realloc=_realloc
  ILINK.IlinkAdditionalLibs: E:\dev\MiCO_B_v3.2.3\demos\application\xlinksrc\Lib_xlink_app_v34700.Cortex-M4.GCC.release.a
  ILINK.IlinkProgramEntryLabel: moc_app_main
configuration EMW5031 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; MICO_KERNEL; MOC; mocOS_VERSION="v1.0"
  ICCARM.CCIncludePath2: ..\..\..\..\demos\application\wifi_uart; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\Board\EMW5031; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\platform\MCU\MW3xx\peripherals; ..\..\..\..\platform\MCU\MW3xx\moc; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform; ..\..\..\..\Platform\MCU; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries; ..\..\..\..\MICO\core; ..\..\..\..\MICO\security; ..\..\..\..\MICO\system; ..\..\..\..\Platform\Drivers; ..\..\..\..\Platform\Drivers\micokit_ext; ..\..\..\..\Platform\MCU\MW3xx\interface; ..\..\..\..\Platform\MCU\MW3xx\peripherals; ..\..\..\..\Platform\MCU\MW3xx\peripherals/sdk/src/incl/sdk; ..\..\..\..\Platform\MCU\MW3xx\peripherals/sdk/src/incl/platform/os/micortos; ..\..\..\..\Platform\MCU\MW3xx\peripherals/sdk/src/incl/sdk/drivers; ..\..\..\..\Platform\MCU\MW3xx\peripherals/sdk/src/incl/sdk/drivers/mw300; ..\..\..\..\Platform\MCU\MW3xx\peripherals/sdk/src/incl/sdk/drivers/mw300/regs; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\libraries\drivers; ..\..\..\..\MiCO\RTOS\mocOS\mico; ..\..\..\..\libraries\drivers\keypad\gpio_button; ..\..\..\..\platform\MCU\MW3xx
  group Application
    ../../../../demos/application/wifi_uart/: cfunctions.c cfunctions.h cppfunctions.h LocalTcpServer.c mico_config.h MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c RemoteTcpClient.c SppProtocol.c SppProtocol.h UartRecv.c
  group Application/xlinkapp
    ../../../../demos/application/xlinkapp/: OTAupgrade.c OTAupgrade.h xlink_config.c xlink_config.h xlink_DataPointProcess.c xlink_DataPointProcess.h xlink_demo.c xlink_demo.h Xlink_PassThroughProtocol.c Xlink_PassThroughProtocol.h Xlink_PassThroughResolve.c Xlink_PassThroughResolve.h xlink_ringbuf.c xlink_ringbuf.h xlinkHttp.c xlinkHttp.h
  group Application/xlinksrc
    ../../../../demos/application/xlinksrc/: Lib_xlink_app_v34700.Cortex-M4.GCC.release.a xlink_data.h Xlink_Head_Adaptation.h xlink_md5.h xlink_message.h xlink_MXCHIP_mico.h xlink_system.h xlink_type.h
  group Application/youpon
    ../../../../demos/application/youpon/: appmainmsgqueue.c appmainmsgqueue.h cJSON.c cJSON.h devicemanager.c devicemanager.h linkagemanager.c linkagemanager.h mico_config.h MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c networkserver.c networkserver.h panelmanager.c panelmanager.h RemoteTcpClient.c rs485_comm.c rs485_comm.h rs485_uart.c rs485_uart.h rs485parse.c rs485parse.h rs485sensorparse.c rs485sensorparse.h scenemanager.c scenemanager.h sensormanager.c sensormanager.h SppProtocol.c SppProtocol.h timer_task.c timer_task.h timercontrol.c timercontrol.h timerctrl.c timerctrl.h timerinterexec.c timerinterexec.h user_config.h user_data_store.c user_data_store.h user_main.c user_main.h user_uart.c user_uart.h wifi_led.c wifi_led.h zigbeeparse.c zigbeeparse.h
  group Board/MK3031
    ../../../../board/MK3031/: platform.c
  group Board/MK5031
    ../../../../board/EMW5031/: platform.c
  group EMWtest
    ../../../../Demos/emw_test/: excutor.c excutor.h jsmn.c jsmn.h main.c net.c wifi.c
  group EMWtest/demos
    ../../../../Demos/micokit_ext/: ext_ambient_light_sensor.c ext_dc_motor.c ext_environmental_sensor.c ext_infrared_reflective.c ext_light_sensor.c ext_motion_sensor.c ext_oled.c ext_rgb_led.c ext_temp_hum_sensor.c
  group include
    ../../../../include/: common.h debug.h mico.h mico_errno.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h mico_wlan.h MiCOSRPServer.h
  group include/MicoDriver
    ../../../../include/MiCODrivers/: MiCODriverAdc.h MiCODriverGpio.h MiCODriverI2c.h MiCODriverMFiAuth.h MiCODriverPwm.h MiCODriverRng.h MiCODriverRtc.h MiCODriverSpi.h MiCODriverUart.h MiCODriverWdg.h
  group iperf_power
    ../../../../demos/iperf_power/: iperf_power.c
  group libraries/daemons/homekit_server
    ../../../../libraries/daemons/homekit_server/: Lib_HomeKit_Server.Cortex-M4F.IAR.release.a
  group libraries/daemons/http_server
    ../../../../libraries/daemons/http_server/: http-strings.c http_parse.c httpd.c httpd_handle.c httpd_ssi.c httpd_sys.c httpd_wsgi.c
  group libraries/drivers/display/VGM128064
    ../../../../libraries/drivers/display/VGM128064/: AsciiLib.c AsciiLib.h oled.c oled.h oledfont.h
  group libraries/drivers/keypad/gpio_button
    ../../../../libraries/drivers/keypad/gpio_button/: button.c button.h
  group libraries/drivers/led/P9813
    ../../../../libraries/drivers/rgb_led/P9813/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group libraries/drivers/MFiAuth
    ../../../../libraries/drivers/MiCODriverMFiAuth/: MiCODriverMFiAuth.a
  group libraries/drivers/MiCOKit-EXT
    ../../../../libraries/drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext_mfg.c motion_sensor.c temp_hum_sensor.c
  group libraries/drivers/MiCOKit-STmem
    ../../../../libraries/drivers/MiCOKit_STmems/: MiCOKit_STmems.c
  group libraries/drivers/motor/dc_motor
    ../../../../libraries/drivers/motor/dc_motor/: dc_motor.c
  group libraries/drivers/sensor/ADPS9930
    ../../../../libraries/drivers/sensor/APDS9930/: APDS9930.c APDS9930.h
  group libraries/drivers/sensor/BMA2x2
    ../../../../libraries/drivers/sensor/BMA2x2/: bma2x2.c bma2x2.h bma2x2_user.c bma2x2_user.h
  group libraries/drivers/sensor/BME280
    ../../../../libraries/drivers/sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
  group libraries/drivers/sensor/BMG160
    ../../../../libraries/drivers/sensor/BMG160/: bmg160.c bmg160.h bmg160_user.c bmg160_user.h
  group libraries/drivers/sensor/BMM050
    ../../../../libraries/drivers/sensor/BMM050/: bmm050.c bmm050.h bmm050_user.c bmm050_user.h
  group libraries/drivers/sensor/DHT11
    ../../../../libraries/drivers/sensor/DHT11/: DHT11.c DHT11.h
  group libraries/drivers/sensor/HTS221
    ../../../../libraries/drivers/sensor/HTS221/: hts221.c hts221.h
  group libraries/drivers/sensor/infrared_adc
    ../../../../libraries/drivers/sensor/infrared_adc/: infrared_reflective.c infrared_reflective.h
  group libraries/drivers/sensor/light_adc
    ../../../../libraries/drivers/sensor/light_adc/: light_sensor.c light_sensor.h
  group libraries/drivers/sensor/LPS25HB
    ../../../../libraries/drivers/sensor/LPS25HB/: lps25hb.c lps25hb.h
  group libraries/drivers/sensor/LSM9DS1
    ../../../../libraries/drivers/sensor/LSM9DS1/: lsm9ds1.h lsm9ds1_acc_gyr.c lsm9ds1_mag.c
  group libraries/drivers/sensor/UVIS25
    ../../../../libraries/drivers/sensor/UVIS25/: uvis25.c uvis25.h
  group libraries/drivers/sn3236
    ../../../../libraries/drivers/sn3236/: sn3236ctrl.c sn3236ctrl.h sn3236ctrl2.c sn3236ctrl2.h
  group libraries/drivers/st1615
    ../../../../libraries/drivers/ST1615/: st1615touch.c st1615touch.h
  group libraries/protocols/SNTP
    ../../../../libraries/protocols/SNTP/: sntp.c sntp.h
  group libraries/utilities
    ../../../../libraries/utilities/: AESUtils.c CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group libraries/utilities/base64
    ../../../../libraries/utilities/base64/: base64.c
  group libraries/utilities/jscon_c
    ../../../../libraries/utilities/json_c/: arraylist.c arraylist.h bits.h config.h debug.h json.h json_inttypes.h json_object.c json_object.h json_object_private.h json_tokener.c json_tokener.h json_util.c json_util.h linkhash.c linkhash.h printbuf.c printbuf.h
  group mico/core
    ../../../../MiCO/core/: mico_config.c moc_main.c
  group mico/net/mocIP
    ../../../../MiCO/net/mocIP/mico/: mico_socket.c
  group mico/RTOS
    ../../../../MiCO/RTOS/: mico_rtos_common.c
  group mico/RTOS/mocOS
    ../../../../MiCO/RTOS/mocOS/mico/: mico_rtos.c
  group mico/security
    ../../../../MiCO/security/Sodium/: Lib_Sodium.IAR.release.a
    ../../../../MiCO/security/SRP_6a/: Lib_SRP6a.IAR.release.a
  group mico/security/mocSSL
    ../../../../MiCO/security/TLS/mocSSL/mico/: mico_ssl.c
  group mico/system
    ../../../../MiCO/system/config_server/: config_server.c config_server_menu.c
    ../../../../MiCO/system/command_console/: mico_cli.c
    ../../../../MiCO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c mico_system_time.c system.h system_misc.c
    ../../../../MiCO/system/tftp_ota/: tftp.h tftp_ota.c tftpc.c
  group mico/system/easylink
    ../../../../MiCO/system/easylink/airkiss_discovery/: airkiss_discovery.c
    ../../../../MiCO/system/easylink/MFi_WAC/: Lib_MFi_WAC.Cortex-M4F.IAR.release.a
    ../../../../MiCO/system/easylink/airkiss_discovery/lib_airkiss/: libairkiss.a
    ../../../../MiCO/system/easylink/: system_easylink.c system_easylink_delegate.c system_easylink_wac.c
  group mico/system/mdns
    ../../../../MiCO/system/mdns/: mico_mdns.c mico_mdns.h system_discovery.c
  group mico/system/qc_test
    ../../../../MiCO/system/qc_test/: qc_test.c
    ../../../../MiCO/system/qc_test/internal/: qc_test_cli.c qc_test_gpio.c qc_test_tcpip.c
  group platform
    ../../../../platform/MCU/: moc_platform_common.c platform_nsclock.c
    ../../../../platform/EWARM/: Retarget.c
  group platform/Cortex-M4
    ../../../../platform/Cortex-M4/: platform_core.c
  group platform/MCU/IAR
    ../../../../platform/MCU/MW310/Init/: copy_init3.c data_init3.c data_init3.h zero_init3.c
  group platform/MCU/moc
    ../../../../platform/MCU/MW3xx/moc/: moc_api.c
  group tcp_server
    ../../../../Demos/tcpip/tcp_server/: tcp_server.c
  group udp
    ../../../../Demos/tcpip/udp_boardcast/: udp_broadcast.c
    ../../../../Demos/tcpip/udp_unicast/: udp_unicast.c
  group wifi_test
    ../../../../Demos/http/http_client/: http_client.c
    ../../../../demos/wifi/station/: wifi_station_core_api.c
