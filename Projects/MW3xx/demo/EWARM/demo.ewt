<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MK3031</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>EMW5031</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>xlinkapp</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\OTAupgrade.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\OTAupgrade.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\xlink_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\xlink_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\xlink_DataPointProcess.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\xlink_DataPointProcess.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\xlink_demo.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\xlink_demo.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\Xlink_PassThroughProtocol.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\Xlink_PassThroughProtocol.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\Xlink_PassThroughResolve.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\Xlink_PassThroughResolve.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\xlink_ringbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\xlink_ringbuf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\xlinkHttp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinkapp\xlinkHttp.h</name>
      </file>
    </group>
    <group>
      <name>xlinksrc</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinksrc\Lib_xlink_app_v34700.Cortex-M4.GCC.release.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinksrc\xlink_data.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinksrc\Xlink_Head_Adaptation.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinksrc\xlink_md5.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinksrc\xlink_message.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinksrc\xlink_MXCHIP_mico.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinksrc\xlink_system.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\xlinksrc\xlink_type.h</name>
      </file>
    </group>
    <group>
      <name>youpon</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\appmainmsgqueue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\appmainmsgqueue.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\cJSON.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\cJSON.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\devicemanager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\devicemanager.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\linkagemanager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\linkagemanager.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\mico_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\MICOAppDefine.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\MICOAppEntrance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\MICOBonjour.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\networkserver.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\networkserver.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\panelmanager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\panelmanager.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\RemoteTcpClient.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\rs485_comm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\rs485_comm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\rs485_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\rs485_uart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\rs485parse.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\rs485parse.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\rs485sensorparse.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\rs485sensorparse.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\scenemanager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\scenemanager.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\sensormanager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\sensormanager.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\SppProtocol.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\SppProtocol.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\timer_task.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\timer_task.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\timercontrol.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\timercontrol.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\timerctrl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\timerctrl.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\timerinterexec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\timerinterexec.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\user_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\user_data_store.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\user_data_store.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\user_main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\user_main.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\user_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\user_uart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\wifi_led.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\wifi_led.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\zigbeeparse.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\demos\application\youpon\zigbeeparse.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\cfunctions.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\cfunctions.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\cppfunctions.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\LocalTcpServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\mico_config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\MICOAppDefine.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\MICOAppEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\MICOBonjour.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\RemoteTcpClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\SppProtocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\SppProtocol.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\application\wifi_uart\UartRecv.c</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>MK3031</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3031\platform.c</name>
      </file>
    </group>
    <group>
      <name>MK5031</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\EMW5031\platform.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>EMWtest</name>
    <group>
      <name>demos</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\micokit_ext\ext_ambient_light_sensor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\micokit_ext\ext_dc_motor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\micokit_ext\ext_environmental_sensor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\micokit_ext\ext_infrared_reflective.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\micokit_ext\ext_light_sensor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\micokit_ext\ext_motion_sensor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\micokit_ext\ext_oled.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\micokit_ext\ext_rgb_led.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\micokit_ext\ext_temp_hum_sensor.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\emw_test\excutor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\emw_test\excutor.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\emw_test\jsmn.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\emw_test\jsmn.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\emw_test\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\emw_test\net.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\emw_test\wifi.c</name>
    </file>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\debug.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_errno.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_platform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_rtos.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_security.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_socket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_system.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_wlan.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MiCOSRPServer.h</name>
    </file>
  </group>
  <group>
    <name>iperf_power</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\iperf_power\iperf_power.c</name>
    </file>
  </group>
  <group>
    <name>libraries</name>
    <group>
      <name>daemons</name>
      <group>
        <name>homekit_server</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\homekit_server\Lib_HomeKit_Server.Cortex-M4F.IAR.release.a</name>
        </file>
      </group>
      <group>
        <name>http_server</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\http-strings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\http_parse.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_handle.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_ssi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_sys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_wsgi.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>drivers</name>
      <group>
        <name>display</name>
        <group>
          <name>VGM128064</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\AsciiLib.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\AsciiLib.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\oled.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\oled.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\oledfont.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>keypad</name>
        <group>
          <name>gpio_button</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\keypad\gpio_button\button.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\keypad\gpio_button\button.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>led</name>
        <group>
          <name>P9813</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\rgb_led\P9813\hsb2rgb_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\rgb_led\P9813\hsb2rgb_led.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\rgb_led\P9813\rgb_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\rgb_led\P9813\rgb_led.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>MFiAuth</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCODriverMFiAuth\MiCODriverMFiAuth.a</name>
        </file>
      </group>
      <group>
        <name>MiCOKit-EXT</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext_mfg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\motion_sensor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\temp_hum_sensor.c</name>
        </file>
      </group>
      <group>
        <name>MiCOKit-STmem</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_STmems\MiCOKit_STmems.c</name>
        </file>
      </group>
      <group>
        <name>motor</name>
        <group>
          <name>dc_motor</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\motor\dc_motor\dc_motor.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>sensor</name>
        <group>
          <name>ADPS9930</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\APDS9930\APDS9930.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\APDS9930\APDS9930.h</name>
          </file>
        </group>
        <group>
          <name>BMA2x2</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMA2x2\bma2x2.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMA2x2\bma2x2.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMA2x2\bma2x2_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMA2x2\bma2x2_user.h</name>
          </file>
        </group>
        <group>
          <name>BME280</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BME280\bme280.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BME280\bme280.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BME280\bme280_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BME280\bme280_user.h</name>
          </file>
        </group>
        <group>
          <name>BMG160</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMG160\bmg160.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMG160\bmg160.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMG160\bmg160_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMG160\bmg160_user.h</name>
          </file>
        </group>
        <group>
          <name>BMM050</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMM050\bmm050.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMM050\bmm050.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMM050\bmm050_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMM050\bmm050_user.h</name>
          </file>
        </group>
        <group>
          <name>DHT11</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\DHT11\DHT11.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\DHT11\DHT11.h</name>
          </file>
        </group>
        <group>
          <name>HTS221</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\HTS221\hts221.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\HTS221\hts221.h</name>
          </file>
        </group>
        <group>
          <name>infrared_adc</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\infrared_adc\infrared_reflective.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\infrared_adc\infrared_reflective.h</name>
          </file>
        </group>
        <group>
          <name>light_adc</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\light_adc\light_sensor.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\light_adc\light_sensor.h</name>
          </file>
        </group>
        <group>
          <name>LPS25HB</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LPS25HB\lps25hb.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LPS25HB\lps25hb.h</name>
          </file>
        </group>
        <group>
          <name>LSM9DS1</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LSM9DS1\lsm9ds1.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LSM9DS1\lsm9ds1_acc_gyr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LSM9DS1\lsm9ds1_mag.c</name>
          </file>
        </group>
        <group>
          <name>UVIS25</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\UVIS25\uvis25.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\UVIS25\uvis25.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>sn3236</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sn3236\sn3236ctrl.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sn3236\sn3236ctrl.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sn3236\sn3236ctrl2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sn3236\sn3236ctrl2.h</name>
        </file>
      </group>
      <group>
        <name>st1615</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\ST1615\st1615touch.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\ST1615\st1615touch.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>protocols</name>
      <group>
        <name>SNTP</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\protocols\SNTP\sntp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\protocols\SNTP\sntp.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>utilities</name>
      <group>
        <name>base64</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\base64\base64.c</name>
        </file>
      </group>
      <group>
        <name>jscon_c</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\arraylist.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\arraylist.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\bits.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\debug.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_inttypes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object_private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_tokener.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_tokener.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_util.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_util.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\linkhash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\linkhash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\printbuf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\printbuf.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\AESUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\CheckSumUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\HTTPUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\RingBufferUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SecurityUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SHAUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SocketUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\StringUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TimeUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TLVUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\URLUtils.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>mico</name>
    <group>
      <name>core</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\mico_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\moc_main.c</name>
      </file>
    </group>
    <group>
      <name>net</name>
      <group>
        <name>mocIP</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\net\mocIP\mico\mico_socket.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>RTOS</name>
      <group>
        <name>mocOS</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\mocOS\mico\mico_rtos.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\mico_rtos_common.c</name>
      </file>
    </group>
    <group>
      <name>security</name>
      <group>
        <name>mocSSL</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\TLS\mocSSL\mico\mico_ssl.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\security\Sodium\Lib_Sodium.IAR.release.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SRP_6a\Lib_SRP6a.IAR.release.a</name>
      </file>
    </group>
    <group>
      <name>system</name>
      <group>
        <name>easylink</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\airkiss_discovery\airkiss_discovery.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\MFi_WAC\Lib_MFi_WAC.Cortex-M4F.IAR.release.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\airkiss_discovery\lib_airkiss\libairkiss.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\system_easylink.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\system_easylink_delegate.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\system_easylink_wac.c</name>
        </file>
      </group>
      <group>
        <name>mdns</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mdns\mico_mdns.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mdns\mico_mdns.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mdns\system_discovery.c</name>
        </file>
      </group>
      <group>
        <name>qc_test</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\qc_test.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\internal\qc_test_cli.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\internal\qc_test_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\internal\qc_test_tcpip.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\config_server\config_server.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\config_server\config_server_menu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\command_console\mico_cli.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_monitor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_notification.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_para_storage.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_power_daemon.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\system.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\system_misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\tftp_ota\tftp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\tftp_ota\tftp_ota.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\tftp_ota\tftpc.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>platform</name>
    <group>
      <name>Cortex-M4</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\Cortex-M4\platform_core.c</name>
      </file>
    </group>
    <group>
      <name>MCU</name>
      <group>
        <name>IAR</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\MW310\Init\copy_init3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\MW310\Init\data_init3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\MW310\Init\data_init3.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\MW310\Init\zero_init3.c</name>
        </file>
      </group>
      <group>
        <name>moc</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\MW3xx\moc\moc_api.c</name>
        </file>
      </group>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\moc_platform_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\platform_nsclock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\EWARM\Retarget.c</name>
    </file>
  </group>
  <group>
    <name>tcp_server</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\tcpip\tcp_server\tcp_server.c</name>
    </file>
  </group>
  <group>
    <name>udp</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\tcpip\udp_boardcast\udp_broadcast.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\tcpip\udp_unicast\udp_unicast.c</name>
    </file>
  </group>
  <group>
    <name>wifi_test</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\http\http_client\http_client.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\wifi\station\wifi_station_core_api.c</name>
    </file>
  </group>
</project>


